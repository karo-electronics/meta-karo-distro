SRC_URI:remove = "git://source.codeaurora.org/external/imx/opencv-imx.git;protocol=https;branch=master;branch=${SRCBRANCH};name=opencv"
SRC_URI += "git://github.com/nxp-imx/opencv-imx.git;protocol=https;branch=${SRCBRANCH};name=opencv"
