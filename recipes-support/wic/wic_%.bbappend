FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-Karo-wic-source-plugins-with-partition-tar-expor.patch"

