PACKAGECONFIG:append:tx6 = " etnaviv kmsro opengl egl gles gbm dri gallium"
PACKAGECONFIG:append:stm32mp1 = " etnaviv kmsro opengl egl gles gbm dri gallium"
PACKAGECONFIG:append:rzg2 = " egl kmsro panfrost"
