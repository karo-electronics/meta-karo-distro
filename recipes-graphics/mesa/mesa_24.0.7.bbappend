FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-gallium-Add-rzg2l-driver-entrypoint.patch"

