ML_PKGS:remove:mx9-nxp-bsp = " \
    onnxruntime-tests \
"
