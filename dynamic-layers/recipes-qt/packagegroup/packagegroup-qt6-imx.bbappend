QT6_IMAGE_INSTALL_QUICK3D:remove = "qtquick3d-dev qtquick3d-examples"
