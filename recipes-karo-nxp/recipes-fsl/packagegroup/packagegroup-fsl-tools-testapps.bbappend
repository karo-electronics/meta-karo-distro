RDEPENDS:${PN}:remove = "can-utils"
