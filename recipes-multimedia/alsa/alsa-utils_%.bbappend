RDEPENDS:alsa-utils-alsamixer += "ncurses"
