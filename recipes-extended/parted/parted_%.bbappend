PACKAGES:remove[karo-minimal] = "${PN}-ptest"
RDEPENDS:${PN}-ptest:remove[karo-minimal] = "bash coreutils perl util-linux-losetup python3"
