ALTERNATIVE_TARGET:${PN} = "${base_bindir}/tar"
